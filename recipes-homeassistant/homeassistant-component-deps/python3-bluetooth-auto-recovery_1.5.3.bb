SUMMARY = "Bluetooth auto recovery for Python"
HOMEPAGE = "https://github.com/Bluetooth-Devices/bluetooth-auto-recovery"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d8b5b84f8af09011094cd7c29a9f972c"

PYPI_PACKAGE = "bluetooth_auto_recovery"

SRC_URI[sha256sum] = "0b36aa6be84474fff81c1ce328f016a6553272ac47050b1fa60f03e36a8db46d"

inherit pypi python_poetry_core
