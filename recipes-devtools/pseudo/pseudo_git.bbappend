FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-ports-linux-pseudo_wrappers-Avoid-openat2-usage-via-syscall.patch"