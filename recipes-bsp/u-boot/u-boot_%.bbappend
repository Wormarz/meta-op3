do_compile[depends] += "trusted-firmware-a:do_deploy"
